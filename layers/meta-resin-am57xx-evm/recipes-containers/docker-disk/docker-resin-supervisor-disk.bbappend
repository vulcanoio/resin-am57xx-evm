SUPERVISOR_REPOSITORY_am57xx-evm = "resin/armv7hf-supervisor"
LED_FILE_am57xx-evm = "/sys/class/leds/led1/brightness"
