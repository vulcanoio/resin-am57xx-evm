include resin-image.inc

RESIN_BOOT_PARTITION_FILES_append_am57xx-evm = " uEnv.txt_internal:"
